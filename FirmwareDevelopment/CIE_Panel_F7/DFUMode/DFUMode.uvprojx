# Keil uVision project DFUMode.uvprojx, settings and files
target DFUMode (5060960::V5.06 update 7 (build 960)::.\Arm_Compiler_5.06u7)
  device: STM32F767BITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: DFUMode +hex
  AfterMake: C:\Keil_v5\ARM\Arm_Compiler_5.06u7\bin\fromelf.exe --bin --output=./build/Objects/DFUMode.bin ./build/Objects/DFUMode.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F767xx
  c include: ..\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\Drivers\CMSIS\Include;.\src;..\Drivers\STM32F7xx_HAL_Driver\Inc;..\Middlewares\ST\STM32_USB_Device_Library\Class\DFU\Inc;..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\Inc
  memory RVCT4: ROM 0x81c0000 size 0x20000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group Startup
    ./: startup_stm32f767xx.s
  group HAL
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_gpio.c stm32f7xx_ll_usb.c stm32f7xx_hal_cortex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_pcd.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_usart.c stm32f7xx_ll_gpio.c stm32f7xx_ll_rcc.c stm32f7xx_ll_usart.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_ll_fmc.c stm32f7xx_hal_lptim.c stm32f7xx_hal_iwdg.c
  group CMSIS
    ./: system_stm32f7xx.c
  group USB
    ./src/: usb_device.c usb_device.h usbd_conf.c usbd_conf.h usbd_desc.c usbd_desc.h usbd_dfu.c usbd_dfu_flash.c usbd_dfu_flash.h
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group User
    ./src/: main.c usart.c gpio.c irq.c fmc.c ltdc.c sdram.c lptim.c gfx.c gfx.h
