# Keil uVision project CIE_Panel_fw162.uvprojx, settings and files
target CIE (5060960::V5.06 update 7 (build 960)::.\Arm_Compiler_5.06u7)
  device: STM32F767BITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: CIE_Panel +hex
  BeforeMake: .\VesionNumber.exe version.txt ..\..\CIE_Panel_F7\Inc\version.h
  BeforeMake: ..\MDK-ARM\time.bat
  AfterMake: .\CreateDFU .\build\Objects\CIE_Panel.hex CIE .\build\Objects\CIE_Panel.dfu 77.56
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_TIM_REGISTER_CALLBACKS,USE_HAL_UART_REGISTER_CALLBACKS, STM32F767xx, USE_IOEXPANDER EW_MAX_SURFACE_CACHE_SIZE=0x100000 EW_MAX_GLYPH_SURFACE_WIDTH=128 EW_MAX_GLYPH_SURFACE_HEIGHT=128,EW_USE_DOUBLE_BUFFER=1,GSM_HTTP
  c include: ..\Inc;..\Source\MCU\MainModule;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Include;..\Source\MCU\DeviceManager;..\Drivers\BSP\Components;..\Source\EW\PlatformPackage\RTE;..\Source\EW\TargetSpecific;../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/system;../Middlewares/Third_Party/LwIP/src/include/netif/ppp;../Middlewares/Third_Party/LwIP/src/include/lwip;../Middlewares/Third_Party/LwIP/src/include/lwip/apps;../Middlewares/Third_Party/LwIP/src/include/lwip/priv;../Middlewares/Third_Party/LwIP/src/include/lwip/prot;../Middlewares/Third_Party/LwIP/src/include/netif;../Middlewares/Third_Party/LwIP/src/include/posix;../Middlewares/Third_Party/LwIP/src/include/posix/sys;../Middlewares/Third_Party/LwIP/system/arch;../Drivers/STM32F7xx_HAL_Driver/Src;..\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\Drivers\BSP\STM32F769I_EVAL;..\Source\MCU\Network;..\Source\EW\GeneratedCode;..\Source\EW\PlatformPackage\RGB565;..\Source\MCU\DeviceManager;..\Source\Common;..\Source\MCU\Librarys
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1c0000
  memory RVCT5: ROM 0x81c0000 size 0x40000
  memory RVCT9: RAM 0x20000800 size 0x7f800
  memory RVCT10: RAM 0x20000000 size 0x800
  scatter file: ..\ScatterFiles\CIE_Panel_custom.sct
  link misc: --diag_suppress=L6329 --keep=loader.o(bootloader_area)
  group System
    ./: startup_stm32f767xx.s
  group Drivers
    ../Source/MCU/DeviceManager/: stmpe811.c DM_TimerHandler.cpp DM_UartHandler.cpp bsp.h bsp_ts.h bsp767.h DM_BatteryRam.h DM_Handlers.h DM_TimerHandler.h DM_UartHandler.h ft5316.h i2c2.h io.h pca9535e.h sdram.h stmpe811.h stmpe1600.h usbh_ftdi.h bsp.c bsp_ts.c ft5316.c i2c2.c pca9535e.c sdram.c
  group USBDevice
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group USBHost
    ../Source/Mori/Middlewares/ST/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid.c usbh_hid_keybd.c usbh_hid_parser.c
    ../Source/Mori/Middlewares/ST/STM32_USB_Host_Library/Class/HUB/: usbh_hub.c
    ../Source/Mori/Middlewares/ST/STM32_USB_Host_Library/Class/DEVICE/: usbh_dev.c
    ../Source/Mori/Middlewares/ST/STM32_USB_Host_Library/Class/FTDI/: usbh_ftdi.c
    ../Source/Mori/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../Source/Mori/: usbh_conf.c
  group FATFS
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group HALAppUser
    ../Src/: bsp_driver_sd.c bsp_driver_sd_dma.c can.c crc.c dma.c dma2d.c ethernetif.c fatfs.c fmc.c gpio.c i2c.c iwdg.c jpeg.c lptim.c ltdc.c main.c quadspi.c rtc.c sd_diskio.c sdmmc.c spi.c stm32f7xx_hal_msp.c stm32f7xx_hal_spi.c stm32f7xx_it.c system_stm32f7xx.c tim.c usart.c usb_device.c usb_host.c usbd_cdc_if.c usbd_conf.c usbd_desc.c usbh_diskio.c
  group MainModules
    ../Source/MCU/MainModule/: MM_Access.cpp MM_ADC.cpp MM_NCU.cpp MM_Application.cpp MM_ATCommand.cpp MM_Backlight.cpp MM_Buzzer.cpp MM_CAN.cpp MM_CauseAndEffect.cpp MM_Command.cpp MM_CrystalMonitor.cpp MM_CSV.cpp MM_CUtils.cpp MM_DebugPort.cpp MM_DFU.cpp MM_EEPROM.cpp MM_EmbeddedWizard.cpp MM_Ethernet.cpp MM_Device.cpp MM_Evacuate.cpp MM_Fault.cpp MM_GlobalSettings.cpp MM_GPIO.cpp MM_ExportXML.cpp MM_GSM.cpp MM_GSMTest.cpp MM_HTTP.cpp MM_ImportXML.cpp MM_Init.cpp MM_IOStatus.cpp MM_LED.cpp MM_Log.cpp MM_main.cpp MM_MemCheck.cpp MM_MeshLog.cpp MM_Module.cpp MM_NCUPassthrough.cpp MM_PanelIO.cpp MM_PanelNetwork.cpp MM_Pipe.cpp MM_PowerReset.cpp MM_PSU.cpp MM_PSU5.cpp MM_SplashLoader.cpp MM_QuadSPI.cpp MM_RadioDevice.cpp MM_SDFATFS.cpp MM_Settings.cpp MM_RealTimeClock.cpp MM_TouchScreen.cpp MM_USBHost.cpp MM_USBSerial.cpp MM_Utilities.cpp MM_VideoPlayer.cpp MM_TestGSM.cpp MM_MQTT.h MM_TestGSM.h MM_MQTTSupport.cpp MM_AppSupport.cpp
  group Parsers
    ../Source/MCU/Librarys/: JSON.cpp Logger.cpp xml.cpp MQTT.h
    ../Source/MCU/MainModule/: MQTTSocket.cpp
  group EW/Generated
    ../Source/EW/GeneratedCode/: App.c Core.c Effects.c Flat.c Graphics.c OldResources.c Resources.c Steel.c Templates.c Views.c WidgetSet.c XFlat.c
  group EW/Platform
    ../Source/EW/PlatformPackage/RGB565/: ewextgfx.c libewgfx-m7-r180-keil.lib
    ../Source/EW/PlatformPackage/RTE/: ewextrte.c libewrte-m7-keil.lib
    ../Source/EW/Misc/: tlsf.h xprintf.h
  group EW/Misc
    ../Source/EW/Misc/: DeviceDriver.c tlsf.c xprintf.c
  group EW/Target
    ../Source/Common/: CO_Site.h
    ../Source/EW/TargetSpecific/: ew_bsp_clock.c ew_bsp_display.c ew_bsp_event.c ew_bsp_graphics.c ew_bsp_interrupts.c ew_bsp_serial.c
  group SplashBitmap
    ../Source/Resources/: RES_splash_bmp.s
    ../Source/MCU/Network/: mqtt_client.h
  group Common
    ../Source/Common/: CO_device.h CO_RBU.cpp CO_RBU.h CO_Site.cpp
  group BootLoader
    ../Source/MCU/BootLoader/: loader.s
  group HAL
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_eth.c stm32f7xx_hal_exti.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mmc.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_spi.c stm32f7xx_hal_spi_ex.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_adc.c stm32f7xx_ll_crc.c stm32f7xx_ll_dac.c stm32f7xx_ll_dma.c stm32f7xx_ll_dma2d.c stm32f7xx_ll_exti.c stm32f7xx_ll_fmc.c stm32f7xx_ll_gpio.c stm32f7xx_ll_i2c.c stm32f7xx_ll_lptim.c stm32f7xx_ll_pwr.c stm32f7xx_ll_rcc.c stm32f7xx_ll_rng.c stm32f7xx_ll_rtc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_spi.c stm32f7xx_ll_tim.c stm32f7xx_ll_usart.c stm32f7xx_ll_usb.c stm32f7xx_ll_utils.c
  group Azures
    ../Middlewares/Third_Party/azure-iot-sdk-c/c-utility/src/: hmac.c sha1.c sha224.c sha384-512.c usha.c
    ../Source/MCU/Librarys/: base64.c
  group LWIP
    ../Source/MCU/Network/: mqtt.c
