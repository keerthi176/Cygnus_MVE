# Keil uVision project SX1272_Matlab_Slave.uvprojx, settings and files
target SX1272_Matlab_Slave (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L476RETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SX1272_Matlab_Slave +hex
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET_RBU,TARGET_NUCLEO_L476RG,CLOCK_SOURCE=USE_PLL_MSI,TARGET_LIKE_MBED,__MBED__,__CORTEX_M4,DEVICE_RTC,MBED_CONF_TARGET_LSE_AVAILABLE,DEVICE_SPI,DEVICE_INTERRUPTIN,DEVICE_SERIAL,DEVICE_SERIAL_FC,DEVICE_SERIAL_ASYNCH,DEVICE_STDIO_MESSAGES,SX_MOSI=PA_7 ,SX_MISO=PA_6 ,SX_SCLK=PA_5 ,SX_NSS=PA_4 ,SX_RESET=PB_8 ,SX_DIO0=PB_7 ,SX_DIO1=PB_5 ,SX_DIO2=PB_4 ,SX_DIO3=PB_3 ,SX_DIO4=PD_2 ,SX_DIO5=PC_12 ,RBU_AntSw=PH_0 ,RBU_Fake=PH_1 ,ANT1_SEL=PC_8 ,ANT2_SEL=PC_7 ,ANT_TX_NRX=PB_2 ,ANT_RX_NTX=PB_0 ,CN_DEBUG_RX=PC_11 ,CN_DEBUG_TX=PC_10 ,CN_FA_MCP_IN=PC_9 ,CN_FIRE_MCP_IN=PA_8 ,CN_HEAD_PWR_ON=PB_1 ,CN_HEAD_RX=PC_0 ,CN_HEAD_TX=PC_1 ,CN_PA2=PA_2 ,CN_PA3=PA_3 ,CN_PB13=PB_13 ,CN_PB14=PB_14 ,CN_PB6=PB_6 ,CN_PB9=PB_9 ,CN_PC2=PC_2 ,CN_PC3=PC_3 ,CN_PC4=PC_4 ,CN_PC5=PC_5 ,CN_PPU_CTS=PA_11 ,CN_PPU_RTS=PA_12 ,CN_PPU_RX=PA_10 ,CN_PPU_TX=PA_9 ,CN_STATUS_LED1=PB_11 ,CN_STATUS_LED2=PB_10 ,CN_STATUS_LED3=PA_15 ,CN_SVI_PWR_ON=PC_6 ,CN_TAMPER1=PC_13 ,CN_TAMPER2=PA_0 ,MAIN_BAT_IRQ=PB_12 ,TEMP_IN=PA_1 ,TEMP_ENABLE=PB_15
  c misc: --preinclude=mbed_config.h
  c include: ..\SX1272_Matlab_Slave;..\..\..\common\mbed-dev;..\..\..\common\mbed-dev\drivers;..\..\..\common\mbed-dev\hal;..\..\..\common\mbed-dev\hal\storage_abstraction;..\..\..\common\mbed-dev\platform;..\..\..\common\mbed-dev\targets;..\..\..\common\mbed-dev\targets\TARGET_STM;..\..\..\common\mbed-dev\targets\TARGET_STM\TARGET_STM32L4;..\..\..\common\mbed-dev\targets\TARGET_STM\TARGET_STM32L4\device;..\..\..\common\mbed-dev\targets\TARGET_STM\TARGET_STM32L4\TARGET_STM32L476xG;..\..\..\common\mbed-dev\targets\TARGET_STM\TARGET_STM32L4\TARGET_STM32L476xG\device;..\..\..\common\mbed-dev\targets\TARGET_STM\TARGET_STM32L4\TARGET_STM32L476xG\TARGET_NUCLEO_L476RG;..\..\..\common\SX1272Lib;..\..\..\common\SX1272Lib\enums;..\..\..\common\SX1272Lib\radio;..\..\..\common\SX1272Lib\registers;..\..\..\common\SX1272Lib\sx1272;..\..\..\common\SX1272Lib\typedefs
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: ..\..\..\common\mbed-dev\targets\TARGET_STM\TARGET_STM32L4\TARGET_STM32L476xG\device\TOOLCHAIN_ARM_STD\stm32l476xx.sct
  group SX1272_Matlab_Slave
    ./: main.cpp main.h main_global.h mbed_config.h
  group SX1272Lib
    ../../../common/SX1272Lib/enums/: enums.h
    ../../../common/SX1272Lib/radio/: radio.cpp radio.h
    ../../../common/SX1272Lib/registers/: sx1272Regs-Fsk.h sx1272Regs-LoRa.h
    ../../../common/SX1272Lib/sx1272/: sx1272.cpp sx1272.h sx1272-hal.cpp sx1272-hal.h
    ../../../common/SX1272Lib/typedefs/: typedefs.h
  group mbed-dev
    ../../../common/mbed-dev/drivers/: AnalogIn.cpp AnalogIn.h AnalogOut.h BusIn.cpp BusIn.h BusInOut.cpp BusInOut.h BusOut.cpp BusOut.h CAN.cpp CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.cpp Ethernet.h FlashIAP.cpp FlashIAP.h I2C.cpp I2C.h I2CSlave.cpp I2CSlave.h InterruptIn.cpp InterruptIn.h InterruptManager.cpp InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.cpp RawSerial.h Serial.cpp Serial.h SerialBase.cpp SerialBase.h SPI.cpp SPI.h SPISlave.cpp SPISlave.h Ticker.cpp Ticker.h Timeout.cpp Timeout.h Timer.cpp Timer.h TimerEvent.cpp TimerEvent.h UARTSerial.cpp UARTSerial.h
    ../../../common/mbed-dev/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h emac_api.h ethernet_api.h flash_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h mbed_flash_api.c mbed_gpio.c mbed_lp_ticker_api.c mbed_pinmap_common.c mbed_sleep_manager.c mbed_ticker_api.c mbed_us_ticker_api.c pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    ../../../common/mbed-dev/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
    ../../../common/mbed-dev/platform/: ATCmdParser.cpp ATCmdParser.h Callback.h CallChain.cpp CallChain.h CircularBuffer.h critical.h CriticalSectionLock.h CThunk.h DeepSleepLock.h DirHandle.h FileBase.cpp FileBase.h FileHandle.cpp FileHandle.h FileLike.h FilePath.cpp FilePath.h FileSystemHandle.cpp FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.cpp LocalFileSystem.h mbed_alloc_wrappers.cpp mbed_application.c mbed_application.h mbed_assert.c mbed_assert.h mbed_board.c mbed_critical.c mbed_critical.h mbed_debug.h mbed_error.c mbed_error.h mbed_interface.c mbed_interface.h mbed_mem_trace.cpp mbed_mem_trace.h mbed_mktime.c mbed_mktime.h mbed_poll.cpp mbed_poll.h mbed_preprocessor.h mbed_retarget.cpp mbed_retarget.h mbed_rtc_time.cpp mbed_rtc_time.h mbed_sdk_boot.c mbed_semihost_api.c mbed_semihost_api.h mbed_sleep.h mbed_stats.c mbed_stats.h mbed_toolchain.h mbed_wait_api.h mbed_wait_api_no_rtos.c mbed_wait_api_rtos.cpp NonCopyable.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h sleep.h Stream.cpp Stream.h toolchain.h Transaction.h wait_api.h
    ../../../common/mbed-dev/targets/TARGET_STM/: analogin_api.c analogout_api.c can_api.c gpio_api.c gpio_irq_api.c gpio_object.h hal_tick_16b.c hal_tick_32b.c i2c_api.c lp_ticker.c mbed_overrides.c mbed_rtx.h nvic_addr.h PeripheralPins.h pinmap.c PinNamesTypes.h port_api.c PortNames.h pwmout_api.c rtc_api.c rtc_api_hal.h serial_api.c serial_api_hal.h sleep.c stm_spi_api.c stm32_assert.h trng_api.c us_ticker_16b.c us_ticker_32b.c
    ../../../common/mbed-dev/targets/TARGET_STM/TARGET_STM32L4/: analogin_device.c analogout_device.c can_device.h common_objects.h device.h flash_api.c gpio_irq_device.c gpio_irq_device.h i2c_device.h pin_device.h pwmout_device.c pwmout_device.h serial_device.c spi_api.c spi_device.h
    ../../../common/mbed-dev/targets/TARGET_STM/TARGET_STM32L4/device/: stm32_hal_legacy.h stm32l4xx_hal.c stm32l4xx_hal.h stm32l4xx_hal_adc.c stm32l4xx_hal_adc.h stm32l4xx_hal_adc_ex.c stm32l4xx_hal_adc_ex.h stm32l4xx_hal_can.c stm32l4xx_hal_can.h stm32l4xx_hal_comp.c stm32l4xx_hal_comp.h stm32l4xx_hal_conf.h stm32l4xx_hal_cortex.c stm32l4xx_hal_cortex.h stm32l4xx_hal_crc.c stm32l4xx_hal_crc.h stm32l4xx_hal_crc_ex.c stm32l4xx_hal_crc_ex.h stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp.h stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_cryp_ex.h stm32l4xx_hal_dac.c stm32l4xx_hal_dac.h stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dac_ex.h stm32l4xx_hal_dcmi.c stm32l4xx_hal_dcmi.h stm32l4xx_hal_def.h stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm.h stm32l4xx_hal_dma.c stm32l4xx_hal_dma.h stm32l4xx_hal_dma2d.c stm32l4xx_hal_dma2d.h stm32l4xx_hal_firewall.c stm32l4xx_hal_firewall.h stm32l4xx_hal_flash.c stm32l4xx_hal_flash.h stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ex.h stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_flash_ramfunc.h stm32l4xx_hal_gpio.c stm32l4xx_hal_gpio.h stm32l4xx_hal_gpio_ex.h stm32l4xx_hal_hash.c stm32l4xx_hal_hash.h stm32l4xx_hal_hash_ex.c stm32l4xx_hal_hash_ex.h stm32l4xx_hal_hcd.c stm32l4xx_hal_hcd.h stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c.h stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_i2c_ex.h stm32l4xx_hal_irda.c stm32l4xx_hal_irda.h stm32l4xx_hal_irda_ex.h stm32l4xx_hal_iwdg.c stm32l4xx_hal_iwdg.h stm32l4xx_hal_lcd.c stm32l4xx_hal_lcd.h stm32l4xx_hal_lptim.c stm32l4xx_hal_lptim.h stm32l4xx_hal_nand.c stm32l4xx_hal_nand.h stm32l4xx_hal_nor.c stm32l4xx_hal_nor.h stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp.h stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_opamp_ex.h stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd.h stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pcd_ex.h stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr.h stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_pwr_ex.h stm32l4xx_hal_qspi.c stm32l4xx_hal_qspi.h stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc.h stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rcc_ex.h stm32l4xx_hal_rng.c stm32l4xx_hal_rng.h stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc.h stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_rtc_ex.h stm32l4xx_hal_sai.c stm32l4xx_hal_sai.h stm32l4xx_hal_sd.c stm32l4xx_hal_sd.h stm32l4xx_hal_smartcard.c stm32l4xx_hal_smartcard.h stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_smartcard_ex.h stm32l4xx_hal_smbus.c stm32l4xx_hal_smbus.h stm32l4xx_hal_spi.c stm32l4xx_hal_spi.h stm32l4xx_hal_spi_ex.c stm32l4xx_hal_spi_ex.h stm32l4xx_hal_sram.c stm32l4xx_hal_sram.h stm32l4xx_hal_swpmi.c stm32l4xx_hal_swpmi.h stm32l4xx_hal_tim.c stm32l4xx_hal_tim.h stm32l4xx_hal_tim_ex.c stm32l4xx_hal_tim_ex.h stm32l4xx_hal_tsc.c stm32l4xx_hal_tsc.h stm32l4xx_hal_uart.c stm32l4xx_hal_uart.h stm32l4xx_hal_uart_ex.c stm32l4xx_hal_uart_ex.h stm32l4xx_hal_usart.c stm32l4xx_hal_usart.h stm32l4xx_hal_usart_ex.h stm32l4xx_hal_wwdg.c stm32l4xx_hal_wwdg.h stm32l4xx_ll_adc.c stm32l4xx_ll_adc.h stm32l4xx_ll_bus.h stm32l4xx_ll_comp.c stm32l4xx_ll_comp.h stm32l4xx_ll_cortex.h stm32l4xx_ll_crc.c stm32l4xx_ll_crc.h stm32l4xx_ll_crs.c stm32l4xx_ll_crs.h stm32l4xx_ll_dac.c stm32l4xx_ll_dac.h stm32l4xx_ll_dma.c stm32l4xx_ll_dma.h stm32l4xx_ll_dma2d.c stm32l4xx_ll_dma2d.h stm32l4xx_ll_exti.c stm32l4xx_ll_exti.h stm32l4xx_ll_fmc.c stm32l4xx_ll_fmc.h stm32l4xx_ll_gpio.c stm32l4xx_ll_gpio.h stm32l4xx_ll_i2c.c stm32l4xx_ll_i2c.h stm32l4xx_ll_iwdg.h stm32l4xx_ll_lptim.c stm32l4xx_ll_lptim.h stm32l4xx_ll_lpuart.c stm32l4xx_ll_lpuart.h stm32l4xx_ll_opamp.c stm32l4xx_ll_opamp.h stm32l4xx_ll_pwr.c stm32l4xx_ll_pwr.h stm32l4xx_ll_rcc.c stm32l4xx_ll_rcc.h stm32l4xx_ll_rng.c stm32l4xx_ll_rng.h stm32l4xx_ll_rtc.c stm32l4xx_ll_rtc.h stm32l4xx_ll_sdmmc.c stm32l4xx_ll_sdmmc.h stm32l4xx_ll_spi.c stm32l4xx_ll_spi.h stm32l4xx_ll_swpmi.c stm32l4xx_ll_swpmi.h stm32l4xx_ll_system.h stm32l4xx_ll_tim.c stm32l4xx_ll_tim.h stm32l4xx_ll_usart.c stm32l4xx_ll_usart.h stm32l4xx_ll_usb.c stm32l4xx_ll_usb.h stm32l4xx_ll_utils.c stm32l4xx_ll_utils.h stm32l4xx_ll_wwdg.h system_stm32l4xx.c
    ../../../common/mbed-dev/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L476xG/TARGET_NUCLEO_L476RG/: PeripheralNames.h PeripheralPins.c PinNames.h system_clock.c
    ../../../common/mbed-dev/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L476xG/device/TOOLCHAIN_ARM_STD/: startup_stm32l476xx.S
software components: CMSIS:CORE 5.0.2
