# Keil uVision project MCU.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L476RETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MCU_Debug +hex
  AfterMake: ..\PC\batch\GenBinForBootloadersOnly.bat debug 03-01-22-01
  AfterMake: ..\PC\batch\GenBinForBootloader.bat debug 03-01-22-01
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: BOOTLOADER_BUILD,USE_HAL_DRIVER,USE_NO_TIMER,_DEBUG,USE_NEW_HEAD_INTERFACE,HAL_ADC_MODULE_ENABLED
  c include: .\StateMachine;.\Mesh;.\Bootloader;.\Common;.\DeviceManager;.\DeviceManager\STM32L4xx_HAL_Driver;.\DeviceManager\STM32L4xx_HAL_Driver\Inc;.\MainModule;.\Middlewares\ST\EEPROM_Emul;.\Middlewares\ST\EEPROM_Emul\Core;.\Middlewares\ST\EEPROM_Emul\Porting\STM32L4;.\Configuration;..\..\ThirdParty\STM32_Cryptographic_Library\inc;.\DeviceManager\sx1272
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\ScatterFiles\BOOTLOADER_MCU_Debug.sct
  group MainModule
    ./MainModule/: MM_Main.h MM_NCUApplicationTask.c MM_RBUApplicationTask.c MM_Main.c MM_ApplicationCommon.c MM_MeshTask.c MM_MeshAPI.c MM_Interrupts.c MM_MACTask.c MM_ConfigSerialTask.c MM_ATHandleTask.c MM_ATCommand.c MM_CommandProcessor.c MM_GpioTask.c MM_CIEQueueManager.c MM_NeighbourInfo.c MM_PluginInterfaceTask.c MM_PluginQueueManager.c MM_IdleDemon.c MM_TimedEventTask.c MM_PpuManagement.c
    ./Mesh/: MC_MacQueues.c
  group StateMachine
    ./StateMachine/: SM_StateMachine.c
  group Mesh
    ./Mesh/: MC_PUP.c MC_Encryption.c MC_SyncAlgorithm.c MC_AckManagement.c MC_SessionManagement.c MC_TestMode.c MC_MAC.c MC_ChanHopSeqGen.c MC_SACH_Management.c MC_MeshFormAndHeal.c MC_TDM.c MC_TDM_SlotManagement.c MC_PingRecovery.c MC_StateManagement.c
  group Bootloader
    ./Bootloader/: BLF_AppUpdater.c BLF_Boot.c BLF_Main.c BLF_serial_if.c common.c menu.c ymodem.c simple.c
  group Common
    ./Common/: CO_Defines.h CO_Message.h CO_ErrorCode.h utilities.c CO_HexString.c CO_SerialDebug.c CO_Queue.c
  group Middlewares
    ./Middlewares/ST/EEPROM_Emul/Core/: eeprom_emul.c
  group DeviceManager
    ./DeviceManager/: DM_ADC.c DM_BatteryMonitor.c DM_IWDG.c DM_FA_NonLatchingButton.c DM_NVM.c DM_SerialPort.c DM_Device.c DM_MCUPower.c DM_Log.c DM_InputMonitor.c DM_OutputManagement.c DM_LED.c DM_i2c.c DM_SystemClock.c DM_CRC.c DM_RNG.c DM_svi.c DM_RelayControl.c gpio_config.c lptim.c board.c spi-board.c gpio-board.c sx1272-board.c gpio.c delay.c STM32L4xx_DB_OPT.s
    ./Middlewares/ST/EEPROM_Emul/Porting/STM32L4/: flash_interface.c
    ./DeviceManager/sx1272/: sx1272.c
  group HAL
    ./DeviceManager/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_flash.c stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_lptim.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c
    ./DeviceManager/STM32L4xx_HAL_Driver/: stm32l4xx_hal_msp.c
    ./DeviceManager/: stm32l4xx_it.c
  group Configuration
    ./Configuration/: DM_NVM_cfg.c DM_SerialPort_cfg.c DM_LED_cfg.c MM_ATHandle_cfg.c MM_ATHandle_PPUcfg.c MM_ConfigSerial_cfg.c MC_MacConfiguration.c CFG_Device_cfg.c
  group CryptoLib
    ../../ThirdParty/STM32_Cryptographic_Library/binary/MK-ARM/: M4_CryptoFW_2_0_6.lib
  group Scripts
    ./ScatterFiles/: BOOTLOADER_MCU_Debug.sct BOOTLOADER_MCU_RELEASE.sct
    ../PC/batch/: GenBinForBootloader.bat GenBinForBootloadersOnly.bat
target Release (5060960::V5.06 update 7 (build 960)::.\Arm_Compiler_5.06u7)
  device: STM32L476RETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: as above
  output: MCU_Release +hex
  AfterMake: ..\PC\batch\GenBinForBootloadersOnly.bat release 03-01-22-01
  AfterMake: ..\PC\batch\GenBinForBootloader.bat release 03-01-22-01
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: BOOTLOADER_BUILD,USE_HAL_DRIVER,USE_NO_TIMER,USE_NEW_HEAD_INTERFACE,HAL_ADC_MODULE_ENABLED
  c include: .\MainModule;.\StateMachine;.\Mesh;.\Bootloader;.\Common;.\DeviceManager;.\DeviceManager\STM32L4xx_HAL_Driver;.\DeviceManager\STM32L4xx_HAL_Driver\Inc;.\Middlewares\ST\EEPROM_Emul;.\Middlewares\ST\EEPROM_Emul\Core;.\Middlewares\ST\EEPROM_Emul\Porting\STM32L4;.\Configuration;..\..\ThirdParty\STM32_Cryptographic_Library\inc;.\DeviceManager\sx1272
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\ScatterFiles\BOOTLOADER_MCU_RELEASE.sct
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS:Keil RTX 4.82.0, Device:Startup 1.3.2
