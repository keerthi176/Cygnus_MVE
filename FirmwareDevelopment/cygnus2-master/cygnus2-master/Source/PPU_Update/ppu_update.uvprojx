# Keil uVision project ppu_update.uvprojx, settings and files
target Main (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32L476RETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: ppu_update +hex
  AfterMake: D:\cygnus2\Source\PC\batch\GenBinForPpuUpdate.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=6 wLevel=2
  c define: BOOTLOADER_BUILD,TARGET_RBU,TARGET_NUCLEO_L476RG,CLOCK_SOURCE=USE_PLL_HSI,TARGET_LIKE_MBED,__MBED__,__CORTEX_M4,DEVICE_RTC,MBED_CONF_TARGET_LSE_AVAILABLE,DEVICE_SPI,DEVICE_INTERRUPTIN,DEVICE_SERIAL,DEVICE_SERIAL_FC,DEVICE_SERIAL_ASYNCH,DEVICE_STDIO_MESSAGES,SX_MOSI=PA_7 ,SX_MISO=PA_6 ,SX_SCLK=PA_5 ,SX_NSS=PA_4 ,SX_RESET=PB_8 ,SX_DIO0=PB_7 ,SX_DIO1=PB_5 ,SX_DIO2=PB_4 ,SX_DIO3=PB_3 ,SX_DIO4=PD_2 ,SX_DIO5=PC_12 ,RBU_AntSw=PH_0 ,RBU_Fake=PH_1 ,ANT1_SEL=PC_8 ,ANT2_SEL=PC_7 ,ANT_TX_NRX=PB_2 ,ANT_RX_NTX=PB_0 ,CN_DEBUG_RX=PC_11 ,CN_DEBUG_TX=PC_10 ,CN_FA_MCP_IN=PC_9 ,CN_FIRE_MCP_IN=PA_8 ,CN_HEAD_PWR_ON=PB_1 ,CN_HEAD_RX=PC_0 ,CN_HEAD_TX=PC_1 ,CN_PA2=PA_2 ,CN_PA3=PA_3 ,CN_PB13=PB_13 ,CN_PB14=PB_14 ,CN_PB6=PB_6 ,CN_PB9=PB_9 ,CN_PC2=PC_2 ,CN_PC3=PC_3 ,CN_PC4=PC_4 ,CN_PC5=PC_5 ,CN_PPU_CTS=PA_11 ,CN_PPU_RTS=PA_12 ,CN_PPU_RX=PA_10 ,CN_PPU_TX=PA_9 ,CN_STATUS_LED1=PC_7 ,CN_STATUS_LED2=PC_6 ,CN_STATUS_LED3=PA_15 ,CN_SVI_PWR_ON=PC_6 ,CN_TAMPER1=PC_13 ,CN_TAMPER2=PA_0 ,MAIN_BAT_IRQ=PB_12 ,TEMP_IN=PA_1 ,TEMP_ENABLE=PB_15
  c misc: --preinclude=mbed_config.h
  c include: .;..\rbu_bringup\tests\common\mbed-dev;..\rbu_bringup\tests\common\mbed-dev\cmsis;..\rbu_bringup\tests\common\mbed-dev\cmsis\TARGET_CORTEX_M;..\rbu_bringup\tests\common\mbed-dev\drivers;..\rbu_bringup\tests\common\mbed-dev\hal;..\rbu_bringup\tests\common\mbed-dev\hal\storage_abstraction;..\rbu_bringup\tests\common\mbed-dev\platform;..\rbu_bringup\tests\common\mbed-dev\targets;..\rbu_bringup\tests\common\mbed-dev\targets\TARGET_STM;..\rbu_bringup\tests\common\mbed-dev\targets\TARGET_STM\TARGET_STM32L4;..\rbu_bringup\tests\common\mbed-dev\targets\TARGET_STM\TARGET_STM32L4\TARGET_STM32L476xG;..\rbu_bringup\tests\common\mbed-dev\targets\TARGET_STM\TARGET_STM32L4\TARGET_STM32L476xG\TARGET_NUCLEO_L476RG;..\rbu_bringup\tests\common\mbed-dev\targets\TARGET_STM\TARGET_STM32L4\TARGET_STM32L476xG\device;..\rbu_bringup\tests\common\mbed-dev\targets\TARGET_STM\TARGET_STM32L4\device;..\rbu_bringup\tests\common\SX1272Lib;..\rbu_bringup\tests\common\SX1272Lib\registers;..\rbu_bringup\tests\common\SX1272Lib\enums;..\rbu_bringup\tests\common\SX1272Lib\typedefs;..\rbu_bringup\tests\common\SX1272Lib\radio;..\rbu_bringup\tests\common\SX1272Lib\sx1272;.\Source
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\ScatterFiles\BOOTLOADER_PPU_UPDATE.sct
  group Source
    ./Source/: main.cpp main.h error_handler.cpp common.h handlers.cpp
  group Lib
    ../rbu_bringup/tests/common/mbed-dev/targets/TARGET_STM/TARGET_STM32L4/device/: stm32l4xx_hal_iwdg.c stm32l4xx_hal_uart.c stm32l4xx_hal_dma.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c
    ../rbu_bringup/tests/common/SX1272Lib/sx1272/: sx1272.cpp sx1272-hal.cpp
    ../rbu_bringup/tests/common/mbed-dev/drivers/: RawSerial.cpp Serial.cpp SerialBase.cpp InterruptIn.cpp SPI.cpp Ticker.cpp TimerEvent.cpp Timeout.cpp
    ../rbu_bringup/tests/common/mbed-dev/targets/TARGET_STM/: serial_api.c pinmap.c gpio_api.c gpio_irq_api.c us_ticker_32b.c stm_spi_api.c
    ../rbu_bringup/tests/common/mbed-dev/targets/TARGET_STM/TARGET_STM32L4/: serial_device.c gpio_irq_device.c spi_api.c
    ../rbu_bringup/tests/common/mbed-dev/hal/: mbed_gpio.c mbed_pinmap_common.c mbed_lp_ticker_api.c mbed_ticker_api.c mbed_us_ticker_api.c mbed_sleep_manager.c
    ../rbu_bringup/tests/common/mbed-dev/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L476xG/TARGET_NUCLEO_L476RG/: PeripheralPins.c
    ../rbu_bringup/tests/common/mbed-dev/platform/: Stream.cpp mbed_retarget.cpp FileBase.cpp FilePath.cpp mbed_board.c FileHandle.cpp mbed_critical.c mbed_error.c mbed_assert.c mbed_wait_api_no_rtos.c
    ../rbu_bringup/tests/common/SX1272Lib/radio/: radio.cpp
software components: CMSIS:CORE 5.4.0, Device:Startup 1.3.1
